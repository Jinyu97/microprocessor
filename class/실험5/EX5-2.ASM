	PROCESSOR 16F876A

	INCLUDE <P16F876A.INC>

	ORG	0000
	BSF	STATUS, RP0
	MOVLW	B'00001111'
	MOVWF	TRISA
	MOVLW	B'00000000'
	MOVWF	TRISC
	MOVLW	B'00000111'
	MOVWF	ADCON1
	BCF	STATUS, RP0
		
		
; MAIN (4, 6 동시에 누를 경우 소리내기)
	MOVLW	B'00001011'	; RC3=0, RC2,1,0=1
	MOVWF	PORTC
LP	MOVF	PORTA, W
	ANDLW	B'00000111'
	SUBLW	B'00000010'
	BTFSC	STATUS, Z
	GOTO	BUZZON
	GOTO	BUZZOFF
		
BUZZON	
	BSF	PORTA,	4	; BUZZER ON
	GOTO	LP
		
BUZZOFF	
	BCF	PORTA,	4	; BUZZER OFF
	GOTO	LP
		
	END