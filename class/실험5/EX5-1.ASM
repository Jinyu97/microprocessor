	PROCESSOR 16F876A

	INCLUDE <P16F876A.INC>

		
	ORG	0000
	BSF	STATUS, RP0
	MOVLW	B'00001111'
	MOVWF	TRISA
	MOVLW	B'00000000'
	MOVWF	TRISC
	MOVLW	B'00000111'
	MOVWF	ADCON1
	BCF	STATUS, RP0
		
		
; MAIN (2 ���� ��� �Ҹ�����)
	MOVLW	B'00000111'	; RC3=0, RB2,1,0=1
	MOVWF	PORTC
LP	MOVF	PORTA, W
	ANDLW	B'00001111'
	SUBLW	B'00001101' 	
	BTFSC	STATUS, Z
	GOTO	BUZZON
	GOTO	BUZZOFF
		
BUZZON	
	BSF	PORTA,	4	; BUZZER ON
	GOTO	LP
		
BUZZOFF	
	BCF	PORTA,	4	; BUZZER OFF
	GOTO	LP
		
	END